# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: oled +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51 oled.c main.c ds1302.c dht11.c keyscan.c mp3.c delay.c alarm.c settings.c lunar.c mq2.c
